# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RB ST STM32F103RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103xE; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\libraries\STM32F1xx_HAL\CMSIS\Include; ..\..\..\..\libcpu\arm\cortex-m3; ..\..\libraries\HAL_Drivers; ..\..\..\..\components\libc\compilers\common; ..\..\..\..\include; ..\..\libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc; applications; ..\..\..\..\libcpu\arm\common; board; ..\..\..\..\components\finsh; ..\..\libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include; board\CubeMX_Config\Inc; .; ..\..\libraries\HAL_Drivers\config; ..\..\..\..\components\drivers\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCOptLevel: 3
  group Kernel
    ../../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: app_LED_Show.c app_charge.c app_oled.c drv_HAL_main.c drv_adc_user.c drv_canthread.c drv_dac.c drv_iic.c drv_monitor.c drv_test.c func_HW_Pin_Set.c func_adc.c func_buzzer.c func_can.c func_dac.c func_oled.c func_oled_font.c main.c mod_adc.c mod_can.c mod_charge.c mod_oled.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
    ../../libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xe.s
    ../../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_hwtimer.c drv_pwm.c drv_soft_i2c.c drv_adc.c drv_can.c drv_wdt.c drv_common.c
  group cpu
    ../../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m3/: cpuport.c context_iar.S
  group DeviceDrivers
    ../../../../components/drivers/can/: can.c
    ../../../../components/drivers/hwtimer/: hwtimer.c
    ../../../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../../../components/drivers/misc/: pin.c adc.c rt_drv_pwm.c
    ../../../../components/drivers/serial/: serial.c
    ../../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/watchdog/: watchdog.c
  group finsh
    ../../../../components/finsh/: shell.c cmd.c msh.c
  group libc
    ../../../../components/libc/compilers/common/: time.c
  group STM32_HAL
    ../../libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../../libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal.c stm32f1xx_hal_cec.c stm32f1xx_hal_sram.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_i2c.c stm32f1xx_hal_can.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_wwdg.c
