# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RB ST STM32F103RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103x6; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: applications\RGB; applications\SPI; ..\..\libraries\HAL_Drivers; ..\..\..\..\components\libc\compilers\common; ..\..\..\..\components\drivers\spi; board\CubeMX_Config\Inc; .; ..\..\..\..\libcpu\arm\cortex-m3; ..\..\libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc; board; ..\..\libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include; ..\..\..\..\components\drivers\include; ..\..\libraries\STM32F1xx_HAL\CMSIS\Include; applications\EnergyOrganCtrl; applications\Tools; applications\Sensor; applications\Main; ..\..\..\..\include; ..\..\..\..\libcpu\arm\common; ..\..\..\..\components\finsh; applications\Key; ..\..\libraries\HAL_Drivers\config
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCOptLevel: 3
  group Kernel
    ../../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group EnergyOrganCtrl
    applications/EnergyOrganCtrl/: EnergyOrgan_Ctrl.c LightDisplay_Ctrl.c Sensor_Ctrl.c
  group Key
    applications/Key/: drv_key.c
  group Main
    applications/Main/: cpuusage.c drv_HAL_main.c main.c drv_thread.h
  group RGB
    applications/RGB/: drv_HW_pwm.c drv_RGB.c
  group Sensor
    applications/Sensor/: func_Sense.c
  group SPI
    applications/SPI/: drv_HW_SPI.c drv_SPI.c
  group Tools
    applications/Tools/: Reg_Ops.h
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
    ../../libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xb.s
    ../../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_pwm.c drv_spi.c drv_common.c
  group cpu
    ../../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m3/: cpuport.c context_iar.S
  group DeviceDrivers
    ../../../../components/drivers/misc/: pin.c rt_drv_pwm.c
    ../../../../components/drivers/serial/: serial.c
    ../../../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../../../components/finsh/: shell.c cmd.c msh.c
  group libc
    ../../../../components/libc/compilers/common/: time.c
  group STM32_HAL
    ../../libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../../libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal.c stm32f1xx_hal_cec.c stm32f1xx_hal_sram.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_spi.c stm32f1xx_ll_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
