# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F427xx; USE_HAL_DRIVER; ARM_MATH_CM4; ARM_MATH_MATRIX_CHECK; ARM_MATH_ROUNDING; __FPU_PRESENT=1U; __TARGET_FPU_VFP; __FPU_USED=1U; __ARM_FEATURE_DSP=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: applications\Public\SoftMod\Pid; ..\..\libraries\HAL_Drivers; applications\Main; ..\..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc; applications\Public\SoftMod\Inc; applications\Chassis; board\CubeMX_Config\Inc; applications\Public\SoftMod\Motor; applications\Public\Communicate\Gimbal; ..\..\..\..\libcpu\arm\cortex-m4; ..\..\libraries\STM32F4xx_HAL\CMSIS\Include; .; ..\..\..\..\libcpu\arm\common; applications\Public\HardMod\Rgblight; board; applications\Public\SoftMod\Can; ..\..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\components\drivers\include; applications\Public\Communicate\IMU; ..\..\..\..\components\libc\compilers\common; applications\UI; applications\Public\Communicate\Refsystem; applications\Public\HardMod\Buzzer; applications\Public\Communicate\GimMotor; ..\..\..\..\include; applications\Monitor; applications\Public\HardMod\Magazine; ..\..\..\..\components\finsh; applications\Public\Communicate\SC; ..\..\libraries\HAL_Drivers\config
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Kernel
    ../../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Chassis
    applications/Chassis/: app_ChassisCtrl.c drv_EnergyConservation.c drv_ExactSmooth.c drv_MecanOmni.c drv_MotorSync.c drv_smooth.c drv_vector.c drv_wheel.c func_ModeTrigger.c mod_motion.c HChassis_Data.h
  group Main
    applications/Main/: drv_cpuusage.c main.c
  group Monitor
    applications/Monitor/: drv_HardWdt.c drv_iwdg.c drv_monitor.c func_Alarm.c func_MonHandling.c mod_Monitor.c
  group Public/Com
    applications/Public/Communicate/Gimbal/: app_GetGim.c drv_GimbalCom.c
    applications/Public/Communicate/GimMotor/: drv_GimMotor.c
    applications/Public/Communicate/IMU/: drv_IMU.c
    applications/Public/Communicate/Refsystem/: app_GetRef.c drv_CRC.c mod_RefSystem.c
    applications/Public/Communicate/SC/: SuperCap_Com.c
  group Public/HardMod
    applications/Public/HardMod/Buzzer/: drv_buzzer.c
    applications/Public/HardMod/Magazine/: magazine.c
    applications/Public/HardMod/Rgblight/: drv_rgblight.c
  group Public/SoftMod
    applications/Public/SoftMod/Can/: can_receive.c drv_canthread.c
    applications/Public/SoftMod/Inc/: drv_utils.c HThread_data.h HCanID_data.h HRef_ID.h HLxfunc.h HList.h
    applications/Public/SoftMod/Motor/: drv_motor.c
    applications/Public/SoftMod/Pid/: pid.c
  group UI
    applications/UI/: CustomUI.c drv_CustomUI_AuxAiming.c drv_CustomUI_basic.c drv_queue.c drv_ui_list.c func_CustomUI.c CustomUI_GraphParameters.h
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    ../../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f427xx.s
    ../../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_pwm.c drv_can.c drv_wdt.c drv_common.c
  group cpu
    ../../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m4/: cpuport.c context_iar.S
  group DeviceDrivers
    ../../../../components/drivers/can/: can.c
    ../../../../components/drivers/misc/: pin.c rt_drv_pwm.c
    ../../../../components/drivers/serial/: serial.c
    ../../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/watchdog/: watchdog.c
  group finsh
    ../../../../components/finsh/: shell.c cmd.c msh.c
  group libc
    ../../../../components/libc/compilers/common/: time.c
  group STM32_HAL
    ../../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_can.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_lptim.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_wwdg.c
