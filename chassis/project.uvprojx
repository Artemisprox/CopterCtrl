# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __TARGET_FPU_VFP, USE_HAL_DRIVER, __FPU_PRESENT=1U, STM32F427xx, __ARM_FEATURE_DSP=1, ARM_MATH_ROUNDING, ARM_MATH_MATRIX_CHECK, __FPU_USED=1U, ARM_MATH_CM4
  c include: .;..\..\..\..\include;applications\Chassis;applications\Main;applications\Public\Communicate\Gimbal;applications\Public\Communicate\GimMotor;applications\Public\Communicate\IMU;applications\Public\Communicate\Refsystem;applications\Public\Communicate\SC;applications\Public\SoftMod\Can;applications\Public\SoftMod\Inc;applications\UI;board;board\CubeMX_Config\Inc;..\..\libraries\HAL_Drivers;..\..\libraries\HAL_Drivers\config;..\..\..\..\libcpu\arm\common;..\..\..\..\libcpu\arm\cortex-m4;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;..\..\..\..\components\finsh;..\..\..\..\components\libc\compilers\common;..\..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;..\..\libraries\STM32F4xx_HAL\CMSIS\Include;..\..\PublicLib\Hardware\Buzzer;..\..\PublicLib\Hardware\RGBLight;..\..\PublicLib\Monitor;..\..\PublicLib\Software\CPU_Usage;..\..\PublicLib\Software\Motor;..\..\PublicLib\Software\Pid;..\..\PublicLib\Software\Utils
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Kernel
    ../../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Chassis
    applications/Chassis/: app_ChassisCtrl.c drv_EnergyConservation.c drv_ExactSmooth.c drv_MecanOmni.c drv_MotorSync.c drv_smooth.c drv_vector.c drv_wheel.c func_ModeTrigger.c mod_motion.c HChassis_Data.h
  group Main
    applications/Main/: main.c
  group Public/Com
    applications/Public/Communicate/Gimbal/: app_GetGim.c drv_GimbalCom.c
    applications/Public/Communicate/GimMotor/: drv_GimMotor.c
    applications/Public/Communicate/IMU/: drv_IMU.c
    applications/Public/Communicate/Refsystem/: app_GetRef.c drv_CRC.c mod_RefSystem.c
    applications/Public/Communicate/SC/: SuperCap_Com.c
  group Public/SoftMod
    applications/Public/SoftMod/Can/: can_receive.c drv_canthread.c
    applications/Public/SoftMod/Inc/: HThread_data.h HCanID_data.h HRef_ID.h HLxfunc.h HList.h
  group UI
    applications/UI/: CustomUI.c drv_CustomUI_AuxAiming.c drv_CustomUI_basic.c drv_queue.c drv_ui_list.c func_CustomUI.c CustomUI_GraphParameters.h
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    ../../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f427xx.s
    ../../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_pwm.c drv_can.c drv_common.c
  group cpu
    ../../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../../components/drivers/can/: can.c
    ../../../../components/drivers/misc/: pin.c rt_drv_pwm.c
    ../../../../components/drivers/serial/: serial.c
    ../../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/watchdog/: watchdog.c
  group finsh
    ../../../../components/finsh/: shell.c cmd.c msh.c
  group libc
    ../../../../components/libc/compilers/common/: time.c
  group STM32_HAL
    ../../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_can.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_lptim.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_wwdg.c
  group Public/Hardware/Buzzer
    ../../PublicLib/Hardware/Buzzer/: drv_buzzer.c
  group Public/Hardware/Light
    ../../PublicLib/Hardware/RGBLight/: drv_rgblight.c
  group Public/Monitor
    ../../PublicLib/Monitor/: drv_HardWdt.c drv_iwdg.c drv_monitor.c func_MonHandling.c mod_Monitor.c
  group Public/Hardware/Cpu_Usage
    ../../PublicLib/Software/CPU_Usage/: drv_cpuusage.c
  group Public/Software/Motor
    ../../PublicLib/Software/Motor/: drv_motor.c
  group Public/Software/Pid
    ../../PublicLib/Software/Pid/: pid.c
  group Public/Software/Utils
    ../../PublicLib/Software/Utils/: drv_utils.c
software components: CMSIS:CORE 5.3.0, CMSIS:DSP 1.7.0
