# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __TARGET_FPU_VFP, USE_HAL_DRIVER, STM32F407xx, __FPU_PRESENT=1U, __ARM_FEATURE_DSP=1, ARM_MATH_ROUNDING, ARM_MATH_MATRIX_CHECK, __FPU_USED=1U, ARM_MATH_CM4
  c include: .;..\..\..\..\include;applications\copter_motor;applications\EKF;applications\IMU;applications\Main;applications\RC_PPM;applications\Sensors;board;board\CubeMX_Config\Inc;..\..\libraries\HAL_Drivers;..\..\libraries\HAL_Drivers\config;..\..\libraries\HAL_Drivers\drv_flash;..\..\..\..\libcpu\arm\common;..\..\..\..\libcpu\arm\cortex-m4;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\spi;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;..\..\..\..\components\finsh;..\..\..\..\components\libc\compilers\common;..\..\PublicLib\Hardware\Buzzer;..\..\PublicLib\Hardware\Remote;..\..\PublicLib\Monitor;..\..\PublicLib\Software\CPU_Usage;..\..\PublicLib\Software\Filter;..\..\PublicLib\Software\Menu;..\..\PublicLib\Software\Motor;..\..\PublicLib\Software\Pid;..\..\PublicLib\Software\Queue;..\..\PublicLib\Software\SetPlanning;..\..\PublicLib\Software\Utils;..\..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;..\..\libraries\STM32F4xx_HAL\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Kernel
    ../../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group copter_motor
    applications/copter_motor/: drv_PWM_motor.c func_motor.c drv_PWM_motor.h
  group EKF
    applications/EKF/: drv_matrix.c func_EKF.c
  group IMU
    applications/IMU/: drv_HWTimer.c drv_IMU.c drv_spithread.c func_IMUCali.c func_TempCtr.c func_ahrs.c func_bmi088.c mod_Atti.c
  group Main
    applications/Main/: func_MonitorCfg.c main.c drv_thread.h
  group RC_PPM
    applications/RC_PPM/: drv_RC_PPM.c drv_tim13.c drv_RC_PPM.h drv_tim13.h
  group Sensors
    applications/Sensors/: drv_TF_mini.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    ../../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    ../../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_pwm.c drv_spi.c drv_can.c drv_wdt.c drv_common.c
    ../../libraries/HAL_Drivers/drv_flash/: drv_flash_f4.c
  group cpu
    ../../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../../components/drivers/can/: can.c
    ../../../../components/drivers/misc/: pin.c rt_drv_pwm.c
    ../../../../components/drivers/serial/: serial.c
    ../../../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/watchdog/: watchdog.c
  group finsh
    ../../../../components/finsh/: shell.c cmd.c msh.c
  group libc
    ../../../../components/libc/compilers/common/: time.c
  group Public/Hardware/Buzzer
    ../../PublicLib/Hardware/Buzzer/: drv_buzzer.c
  group Public/Hardware/Remote
    ../../PublicLib/Hardware/Remote/: drv_remote.c
  group Public/Monitor
    ../../PublicLib/Monitor/NoMonitor/: mod_Monitor.h
  group Public/Hardware/Cpu_Usage
    ../../PublicLib/Software/CPU_Usage/: drv_cpuusage.c
  group Public/Software/Filter
    ../../PublicLib/Software/Filter/: drv_ExactSmooth.c
  group Public/Software/Menu
    ../../PublicLib/Software/Menu/: drv_Key_Set.h func_Key_Record.c mod_KeyCtrl.c
  group Public/Software/Motor
    ../../PublicLib/Software/Motor/: drv_motor.c
  group Public/Software/Pid
    ../../PublicLib/Software/Pid/: pid.c
  group Public/Software/Queue
    ../../PublicLib/Software/Queue/: drv_Queue.c
  group Public/Software/SetPlanning
    ../../PublicLib/Software/SetPlanning/: drv_SetPlanning.c
  group Public/Software/Utils
    ../../PublicLib/Software/Utils/: drv_utils.c
  group STM32_HAL
    ../../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_spi.c stm32f4xx_hal_qspi.c stm32f4xx_hal_can.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_lptim.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c
software components: CMSIS:CORE 5.2.0, CMSIS:DSP 1.6.0
